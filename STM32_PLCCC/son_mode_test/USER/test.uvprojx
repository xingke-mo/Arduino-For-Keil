# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10X_FWLIB\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\LED;..\HARDWARE\BSP;..\HARDWARE\usart1;..\HARDWARE\DMA;..\HARDWARE\usart2;..\HARDWARE\usart3;..\HARDWARE\card;..\HARDWARE\display;..\HARDWARE\meter;..\HARDWARE\relay;..\HARDWARE\interrupt;..\HARDWARE\rtc;..\HARDWARE\flash;..\HARDWARE\gun;..\HARDWARE\def;..\HARDWARE\usart4;..\HARDWARE\PLCmodule
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c LogicTask.c Target2.c plc.c _3762.c
    //Mac/Home/Documents/GitHub/STM32_PLCCC/STM32_PLCCC_V0/USER/: com2_task.c
  group CORE
    ../CORE/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group SYSTEM
    ../CORE/: core_cm3.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/usart1/: usart1.c
    ../HARDWARE/usart2/: usart2.c
    ../HARDWARE/usart3/: usart3.c
    //Mac/Home/Documents/GitHub/STM32_PLCCC/STM32_PLCCC_V0/HARDWARE/usart4/: usart4.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/interrupt/: interrupt.c
    ../HARDWARE/rtc/: rtc.c
    ../HARDWARE/flash/: flash.c
    //Mac/Home/Documents/GitHub/STM32_PLCCC/STM32_PLCCC_V0/HARDWARE/PLCmodule/: plcmodule.c
  group FWLIB
    ../STM32F10X_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
