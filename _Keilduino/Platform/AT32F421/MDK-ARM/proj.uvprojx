# Keil uVision project proj.uvprojx, settings and files
target AT32F421 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARDUINO=111
  c misc: --gnu --diag_warning=4017
  c include: ..\..\..\Application;..\..\..\ArduinoAPI;..\..\..\Libraries;..\Core;..\Config
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../../../Application/: main.cpp rt_sys.cpp
  group Config
    ../Config/: mcu_config.h
  group ArduinoAPI
    ../../../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: mcu_type.h mcu_core.h mcu_core.c at32f421_clock.c adc.c delay.c exti.c gpio.c timer.c pwm.c rtc.c HardwareSerial.cpp SPI.cpp
  group README
    ../../../: README.md
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.0, Device:at32f421_conf 2.0.0, Device:at32f421_firmware_library:adc 2.0.0, Device:at32f421_firmware_library:cmp 2.0.0, Device:at32f421_firmware_library:crc 2.0.0, Device:at32f421_firmware_library:crm 2.0.0, Device:at32f421_firmware_library:debug 2.0.0, Device:at32f421_firmware_library:dma 2.0.0, Device:at32f421_firmware_library:ertc 2.0.0, Device:at32f421_firmware_library:exint 2.0.0, Device:at32f421_firmware_library:flash 2.0.0, Device:at32f421_firmware_library:gpio 2.0.0, Device:at32f421_firmware_library:i2c 2.0.0, Device:at32f421_firmware_library:misc 2.0.0, Device:at32f421_firmware_library:pwc 2.0.0, Device:at32f421_firmware_library:scfg 2.0.0, Device:at32f421_firmware_library:spi 2.0.0, Device:at32f421_firmware_library:tmr 2.0.0, Device:at32f421_firmware_library:usart 2.0.0, Device:at32f421_firmware_library:wdt 2.0.0, Device:at32f421_firmware_library:wwdt 2.0.0
