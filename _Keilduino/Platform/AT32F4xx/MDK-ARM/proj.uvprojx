# Keil uVision project proj.uvprojx, settings and files
target AT32F4xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F403ACGU7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARDUINO=111
  c misc: --gnu
  c include: ..\..\..\Application;..\..\..\ArduinoAPI;..\..\..\Libraries;..\Config;..\Core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group Application
    ../../../Application/: main.cpp rt_sys.cpp
  group Config
    ../Config/: mcu_config.h
  group ArduinoAPI
    ../../../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Tone.cpp Stream.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: mcu_type.h mcu_core.h mcu_core.c adc.c delay.c exti.c extend_SRAM.c gpio.c pwm.c rtc.c timer.c wdg.c HardwareSerial.cpp SPI.cpp
  group README
    ../../../: README.md
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1, Device:StdPeriph Drivers:ADC 1.0.1, Device:StdPeriph Drivers:BKPR 1.0.1, Device:StdPeriph Drivers:DMA 1.0.1, Device:StdPeriph Drivers:EXTI 1.0.1, Device:StdPeriph Drivers:FMC 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:IWDG 1.0.1, Device:StdPeriph Drivers:PWR 1.0.1, Device:StdPeriph Drivers:RCC 1.0.1, Device:StdPeriph Drivers:RTC 1.0.1, Device:StdPeriph Drivers:SPI 1.0.1, Device:StdPeriph Drivers:TIMER 1.0.1, Device:StdPeriph Drivers:USART 1.0.1, Device:System_AT32Fxx 1.0.1
